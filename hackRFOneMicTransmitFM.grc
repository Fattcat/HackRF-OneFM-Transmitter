options:
  parameters:
    author: fattcat
    generate_options: qt_gui
    id: hackRFOneMicTransmitFM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '3.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '7'
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 107.5e6
    gain0: '10'
    if_gain0: '30'
    sample_rate: samp_rate*100
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_wfm_tx_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_agc_xx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
